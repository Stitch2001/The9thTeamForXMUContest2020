# Keil uVision project F405project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F405project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c include: .\CORE;.\FWLIB\inc;.\USER;.\uCOSIII\uC-LIB;.\uCOSIII\uC-CPU;.\uCOSIII\uCOS-III;.\uCOSIII\uCOS_BSP;.\uCOSIII\uCOS_CONFIG;.\uCOSIII\uCOS-III\Source;.\uCOSIII\uC-CPU\ARM-Cortex-M4\RealView;.\uCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;.\uCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;.\uCOSIII\uCOS_BSP\led;.\uCOSIII\uCOS_BSP\usart;.\SYSTEM;.\RCSLIB;.\USERLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c rcs.h
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uCOS_BSP
    ./uCOSIII/uCOS_BSP/: bsp.c
  group uCOS_CPU
    ./uCOSIII/uC-CPU/: cpu_core.c
    ./uCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group uCOS_LIB
    ./uCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./uCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOS_CORE
    ./uCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOS_PORT
    ./uCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS_CONFIG
    ./uCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group SYSTEM
    ./SYSTEM/: sys.c delay.c usart.c
  group RCSLIB
    ./RCSLIB/: RCS_SPI.c RCS_Types.c RCS_GPIO.c RCS_OLED.c RCS_OLED_ASCII.c RCS_ADC.c RCS_Exti.c RCS_CAN.c RCS_Usart.c RCS_Timer.c RCS_Pwm.c RCS_GROBAL_GPS.c RCS_Ctrl_BaseMove.c RCS_M_BaseMove.c RCS_MOTOR_3508.c RCS_PIDctrl.c RCS_Remote.c RCS_Oled_IIC.c
  group USERLIB
    ./USERLIB/: LED_LIB.c MOTOR_CTRL_LIB.c
